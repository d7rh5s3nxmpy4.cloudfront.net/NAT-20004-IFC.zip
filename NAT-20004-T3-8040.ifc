Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2024-10-31T05:47:19
Written by: Xbim File Processor version 4.0.0.0
Made in: Xbim version 4.0.0.0

# IfcDistributionPort (2)
Name | FlowDirection
 | SOURCE
 | SINK

# IfcFlowTerminal: NAT-20004-T3-8040
Type - Description: Default Lamp Description; PredefinedType: FLUORESCENT
Photometric Information - Lamp names: NAT-20004-T3-8040; Light output ratio: 1; Luminous flux: 4808 lm
Pset_LampTypeCommon - ContributedLuminousFlux: 4808 lm; LightEmitterNominalPower: 40 W; Spectrum: 380: 12934, 385: 1155, 390: 11614, 395: 10494, 400: 10484, 405: 10279, 410: 968, 415: 11352, 420: 17493, 425: 49381, 430: 110001, 435: 213323, 440: 422394, 445: 673726, 450: 939462, 455: 97829, 460: 851938, 465: 670014, 470: 549521, 475: 442322, 480: 39367, 485: 37832, 490: 392506, 495: 423255, 500: 468951, 505: 509823, 510: 551923, 515: 57673, 520: 59894, 525: 611155, 530: 623829, 535: 629598, 540: 636475, 545: 645361, 550: 655589, 555: 671682, 560: 690295, 565: 709359, 570: 730587, 575: 748998, 580: 767832, 585: 786295, 590: 801043, 595: 812518, 600: 821303, 605: 827334, 610: 827494, 615: 819016, 616: 814072, 617: 810179, 618: 806287, 619: 802012, 620: 797737, 625: 764787, 630: 724964, 635: 680899, 640: 638133, 645: 594845, 650: 555125, 655: 51894, 660: 486181, 665: 454614, 670: 422297, 675: 388355, 680: 352992, 685: 318193, 690: 282697, 695: 245701, 700: 215906, 705: 189853, 710: 163229, 715: 14476, 720: 12737, 725: 114158, 730: 97674, 735: 85444, 740: 75708, 745: 68751, 750: 61453, 755: 56451, 760: 52251; ColorTemperature: 4000 K; ColorRenderingIndex: 80

# IfcFlowTerminal: Nature source 1 Post top luminaires
In: Default Building
Type - Description: - Lamp LED - CRI Ra > 80 - MacAdam Ellipse 3 SDCM - Colour 3000K and 4000K - Die-cast aluminium end-caps - Extruded aluminium housing and frame - Pre-treated before powder coating ensuring high corrosion resistance - Thermal heat dissipation body - Stainless steel fasteners in grade 304 with zinc flake coating (ZFC) - Durable silicone rubber gasket - Clear glass diffuser - Integral control gear - Full automatic electronic protection function against short circuit, overcurrent, overload, overvoltage and high temperature - Remote solar charge controller can be ordered as an accessory - Luminaires operation time depends on the weather conditions - Peak Sun-Hour used in the calculations is 3 hours per day - Without any sun (Autonomy), the battery would last for maximum 2.5 days - Motion sensor integrated - Solar module consist of monocrystalline high efficiency cells 5x15W - Lithium Iron Phosphate (LiFePO4 ) battery 2x16.5Ah 12Vdc - Solar charger controller system 12V 10A - Standard: Off-grid, 100% solar, not connected to the utility grid. Utility grid connection is available upon request - Maximum 23 hours of operation time (2 Step dimming) - STD: 2 Step dimming (100% 3 hours, 60% 9 hours), ND: Dusk to Dawn, MS: 2 Step dimming with the motion sensor override (100% 3 hours, 30% without movement, 100% for 1 minute when the motion sensor activated), CT: Custom - Different dimming options are available - Custom dimming (CT) examples are 5 Step dimming, Custom hours, Custom dimming levels (Step length and minimum dim level is 10%); PredefinedType: DIRECTIONSOURCE
Material: layer 10 mm
Marketing Information - Emergency lighting possible: no; Product group: MACARON, Post top luminaires; Housing color: Not specified
General Information - Article number: NAT-20004-T3-8040; Article name: Nature source 1 Post top luminaires; Weight: 25.5 kg; Case length: 60.4 cm; Case width: 111.3 cm; Case height: 53.5 cm; Uld creation date: 31.10.2024 04:47:19
Pset_ElectricalDeviceCommon - ElectricalDeviceNominalPower: 40 W
Pset_LightFixtureTypeCommon - NumberOfSources: 1; TotalWattage: 40 W; LightFixtureMountingType: PoleTop; ManufacturersSpecificInformation: LIGMAN
